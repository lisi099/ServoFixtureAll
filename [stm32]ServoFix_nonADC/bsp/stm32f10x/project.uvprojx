# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output SRT.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .;..\..\include;applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\CMSIS\Include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;.\drivers\Iap;.\drivers\Common
  memory RVCT4: ROM 0x8001800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Kernel
    ../../src/: clock.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c stm32f10x_it.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Menu
    ./drivers/: menu.c menu.h menu_app.c menu_app.h servo_test_callback.c servo_test_callback.h default_callback.c default_callback.h keep_callback.c keep_callback.h memory_callback.c memory_callback.h servo_rw_callback.c servo_rw_callback.h
  group Usart
    ./drivers/: usart1.c usart1.h usart2.c usart2.h pc_cmd.c pc_cmd.h
  group Lcd
    ./drivers/: 1602_iic_sw.c 1602_iic_sw.h
  group ServoMsg
    ./drivers/: servo_serial.h servo_serial.c servo_adc.c servo_adc.h factory_data.h factory_data.c tai_servo.h tai_servo.c tai_pwm.c tai_pwm.h data_base_flash.c data_base_flash.h
  group Common
    ./drivers/Common/: stm32_crc32.h stm32_crc32.c includes.h crc16.h crc16.c board_info.h
  group Upgrade
    ./drivers/Iap/: flash.c flash.h common_fifo.c common_fifo.h usart1_fifo.c usart1_fifo.h usart1_package.c usart1_package.h
  group Button
    ./drivers/: key.h key_array.c
