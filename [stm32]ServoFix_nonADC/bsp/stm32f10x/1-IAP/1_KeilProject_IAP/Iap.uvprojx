# Keil uVision project Iap.uvprojx, settings and files
target STM32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_on +hex
  AfterMake: fromelf --bin !L --output IAP.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\App;..\Bsp;..\Iap;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Common
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Iap/: main.c
  group Iap
    ../Iap/: flash.c flash.h iap.c iap.h led.c led.h system_tick.c system_tick.h usart1.c usart1.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Std_Drivers
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h
  group Common
    ../Common/: board_info.h includes.h crc16.c crc16.h stm32f10x_it.c stm32_crc32.c stm32_crc32.h
